<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ns_us300.ewp</path>
  </project>
  <batchBuild />
</workspace>
