# IAR project ns_us300.ewp, settings and files
configuration ns_us300 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RC ST STM32F205RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx; DEBUG_UART1; CONFIG_MULTI
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ns_us300_$DATE$.hex
  ILINK.IlinkOutputFile: ns_us300.out
  ILINK.IlinkIcfFile: stm32f205xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ns_us300_multi (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: ns_us300_multi_$DATE$.hex
configuration ns_us300_single (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx; DEBUG_UART1; nCONFIG_MULTI
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_$DATE$.hex
  group Application/EWARM
    ./: startup_stm32f205xx.s
  group Application/User
    ../Src/: buffer.c debug.c digport.c hal_nv.c hal_nv.h keyscan.c main.c ringbuffer.c soft_timer.c stm32f2xx_hal_msp.c stm32f2xx_it.c task1.c task1.h task2.c task2.h voice.c xprintf.c
    ../Inc/: keyscan.h main.h
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
